# Keil uVision project led_test.uvprojx, settings and files
target led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_test +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\Libraries\FWlib\inc;.\User;D:\Users\Lenovo\AppData\Local\Arm\Packs\ARM\CMSIS\5.6.0\CMSIS\Include
  asm include: .\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group cmsis
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group fw_lib
    ./Libraries/FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c
  group user
    ./User/: main.c stm32f10x_conf.h
